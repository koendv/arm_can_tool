# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F405RCT7_v2 ArteryTek AT32F405RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; AT32F405RCT7; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\AT32F402_405_Firmware_Library\cmsis\cm4\device_support; ..\..\..\components\finsh; ..\..\..\components\drivers\phy; ..\..\..\components\libc\posix\io\epoll; board\inc; ..\..\..\include; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\libcpu\arm\cortex-m4; board; ..\..\..\components\libc\compilers\common\include; ..\libraries\rt_drivers; ..\..\..\components\drivers\smp_call; .; ..\..\..\components\libc\posix\io\poll; ..\libraries\usbotg_library\inc; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\compilers\common\extension; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\io\eventfd; applications; ..\..\..\components\drivers\include; ..\libraries\AT32F402_405_Firmware_Library\drivers\inc; ..\libraries\rt_drivers\config; ..\libraries\AT32F402_405_Firmware_Library\cmsis\cm4\core_support
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F402_405_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32f402_405.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/AT32F402_405_Firmware_Library/drivers/src/: at32f402_405_usb.c at32f402_405_flash.c at32f402_405_crc.c at32f402_405_dma.c at32f402_405_can.c at32f402_405_wdt.c at32f402_405_tmr.c at32f402_405_qspi.c at32f402_405_pwc.c at32f402_405_scfg.c at32f402_405_exint.c at32f402_405_ertc.c at32f402_405_wwdt.c at32f402_405_usart.c at32f402_405_crm.c at32f402_405_gpio.c at32f402_405_debug.c at32f402_405_spi.c at32f402_405_adc.c at32f402_405_i2c.c at32f402_405_acc.c at32f402_405_misc.c
    ../libraries/AT32F402_405_Firmware_Library/cmsis/cm4/device_support/: system_at32f402_405.c
